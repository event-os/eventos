# Keil uVision project EventOS-Nano.uvprojx, settings and files
target EventOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EventOS-Nano
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX,
  c include: ..\..\..\eventos;..\User;..\MCU;..\..\..\3rd
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: eos_led_reactor.c eos_led_sm.c main.c port_stm32f030.c
  group MCU
    ../MCU/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f0xx.s
  group EventOS
    ../../../eventos/: eventos.c
  group 3rd
    ../../../3rd/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
