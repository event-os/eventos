# Keil uVision project eventos.uvprojx, settings and files
target EventOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: eventos +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx, EOS_MCU,
  c include: ..\APP;..\MCU;..\..\..\eventos;..\..\..\3rd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c eos_led_reactor.c eos_led_sm.c hook.c
    ../../../eventos/: ecp.c elog.c esh.c esh_port.c
  group MCU
    ../MCU/: system_stm32f4xx.c startup_stm32f429_439xx.s
  group EventOS
    ../../../eventos/: eventos.c
    ../../../eos_port/: port_cortex_m.c
