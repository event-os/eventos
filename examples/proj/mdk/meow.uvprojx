# Keil uVision project meow.uvprojx, settings and files
target meow (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: oa +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_M4, __FPU_PRESENT=1,
  c include: hardware\chip_17xx_40xx;hardware\chip_common;hardware\chip_17xx_40xx\config_40xx;hardware\mcu;..\..\meowc;.\hardware;..\..\testc;.\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ../../: main_meow.c
    ../../testc/: led.c
  group meow
    ../../meowc/: meow.c port_mcu.c
  group Mcu
    hardware/mcu/: startup_LPC407x_8x_177x_8x.s
    ./hardware/: bsp.c
  group StdLib
    hardware/chip_17xx_40xx/: chip_17xx_40xx.c clock_17xx_40xx.c iocon_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c
    hardware/chip_common/: fpu_init.c
  group Rtt
    ./rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.0.1
