# Keil uVision project eventos-nano.uvprojx, settings and files
target EventOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: eventos-nano
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F746xx,
  c include: ..\APP;..\MCU;..\..\..\eventos;..\..\..\3rd;..\noise;..\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c hook.c
  group MCU
    ../MCU/: system_stm32f7xx.c startup_stm32f746xx.s
  group EventOS
    ../../../eventos/: eventos.c
    ../../../eos_port/: port_cortex_m.c
